# Keil uVision project BMS_MasterNew.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: BMS_MasterNew
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drivers;.\RTE\Device\SKEAZ128xxx4;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group drivers
    ./drivers/: drivers.c gpio.c ics.c mscan.c pit.c uart.c wdog.c mcp2515.c spi.c adc.c
  group src
    ./src/: candata_service.c data_pack.c debug.c main.c timer.c uart_can.c uartdata_service.c can_out.c insulation_res.c public.c cc1120.c rf_arbitration.c rf_service.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
